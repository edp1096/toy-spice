* Diode Test Circuit. Half wave rectifier
.dc Vin 0 5 50
Vin 1 0 DC 0
d1 1 2 D
r1 2 0 1k
